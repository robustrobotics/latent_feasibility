Commit message: Update stacking_ros with bug real-robot bug fixes

File: tamp/models/walls.urdf (robot description, URDF)
Before this commit: robot walls, 5 links, 4 joints
Joints:
- joint ceiling: origin xyz=-0.767 0.0 0.4 rpy=0 0 0 -> xyz=-0.767 0.0 0.35 rpy=0 0 0
